require nodejs_8.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=1632f8fdb294f7c1f2281ad228aa4099"

SRC_URI[src.md5sum] = "37f899ef9fc17b039c3ea3f895806355"
SRC_URI[src.sha256sum] = "66fe1379bc7daf9a16c6b5c45ab695bf1cdcfae9738d2989e940104d6b31973f"

