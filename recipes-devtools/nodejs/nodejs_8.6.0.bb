require nodejs_8.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=e4d35c6120f175e1fbe5ff908b1cf2d6"

SRC_URI[src.md5sum] = "0c95e08220667d8a18b97ecec8218ac6"
SRC_URI[src.sha256sum] = "80551d47440c602c5825a3f6611e13cb0c57d277234dbff693af433a88351a08"
